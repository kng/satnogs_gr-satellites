options:
  parameters:
    author: sa2kng, some parts from satnogs_bpsk and satnogs_fm
    description: 'replay iq.raw files to udp iq. Example use with: gr_satellites <sat> --samp_rate  48000 --iq --udp --udp_raw --udp_port 57356'
    generate_options: no_gui
    id: iqdump2udp_audio
    output_language: python
    run_options: run
    title: SatNOGS IQ dump to UDP IQ and audio
  states: {}

blocks:
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.015'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*math.pi*deviation)/audio_samp_rate
  states: {}
- name: audio_samp_rate
  id: parameter
  parameters:
    label: audio sample rate
    short_id: a
    type: eng_float
    value: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: raw_file
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16384'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '16384'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/16768
    type: complex
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Add a frequency offset equal the baudrate
      to move the audio representation of the
      signal to the audable frequencies
    phase_inc: 2.0 * math.pi * (if_freq / audio_samp_rate)
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: int(samp_rate)
    type: complex
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      Complex float IQ stream
      Use with:
      gr_satellites <sat> --iq --udp --udp_raw --udp_port 57356 --samp_rate <samp_rate>
    eof: 'True'
    ipaddr: udp_dump_host
    port: udp_dump_port
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      Same output as GQRX audio using SSB demodulation
      Signal shifted up to if_freq
      Use with:
      gr_satellites <bpsk_sat> --udp --udp_port 57357 --samp_rate <audio_samp_rate> --f_offset <if_freq>
    eof: 'True'
    ipaddr: udp_dump_host
    port: udp_dump_port+1
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0_0_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      Same output as GQRX audio using FM demodulation
      Adjust deviation and max_modulation_freq
      Use with:
      gr_satellites <fsk_sat> --udp --udp_port 57358 --samp_rate <audio_samp_rate>
    eof: 'True'
    ipaddr: udp_dump_host
    port: udp_dump_port+2
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: FM deviation (Hz)
    type: eng_float
    value: 5e3
  states: {}
- name: if_freq
  id: parameter
  parameters:
    label: SSB IF frequency
    short_id: i
    type: eng_float
    value: '12000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Using the Carson bandwidth rule for filter width:
      width = 2*(deviation + max_modulation_freq).
      For the majority of FM transmissions we can expect
      max_modulation_freq = 3000
    cutoff_freq: deviation+max_modulation_freq
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.42*audio_samp_rate/2.0
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: 0.05 * audio_samp_rate
    win: firdes.WIN_HAMMING
  states: {}
- name: max_modulation_freq
  id: parameter
  parameters:
    label: The highest frequency in the FM modulating signal
    type: eng_float
    value: 3e3
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '80'
    nfilts: '32'
    rrate: audio_samp_rate/samp_rate
    type: ccf
  states: {}
- name: raw_file
  id: parameter
  parameters:
    label: Input file from satnogs iq dump
    short_id: f
    type: str
    value: ''
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: s
    type: eng_float
    value: '48000'
  states: {}
- name: udp_dump_host
  id: parameter
  parameters:
    label: host/ip to bind udp sink
    short_id: u
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: udp_dump_port
  id: parameter
  parameters:
    label: host port for udp sink
    short_id: p
    type: intx
    value: '57356'
  states: {}

connections:
- [analog_agc2_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [analog_agc2_xx_0_0, '0', low_pass_filter_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_float_to_short_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0_0_0_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_udp_sink_0_0_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_1, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_1, '0', analog_agc2_xx_0, '0']
- [blocks_throttle_1, '0', blocks_udp_sink_0_0_0, '0']
- [blocks_throttle_1, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_float_to_short_0_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', blocks_rotator_cc_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_agc2_xx_0_0, '0']

metadata:
  file_format: 1
