options:
  parameters:
    author: Daniel Ekman <knegge@gmail.com>
    description: convert mono 48k wav to raw/iq at 24k
    generate_options: no_gui
    id: wav2iq
    output_language: python
    run_options: run
    title: wav to iq
  states: {}

blocks:
- name: filter_cutoff
  id: variable
  parameters:
    value: samp_rate // 4
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, filter_cutoff, filter_transition)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: outfile
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: infile
    repeat: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: samp_rate // 4
    decim: '2'
    samp_rate: samp_rate
    taps: taps
    type: fcf
  states: {}
- name: infile
  id: parameter
  parameters:
    label: input
    short_id: i
    type: str
    value: recording.wav
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: output
    short_id: o
    type: str
    value: recording.raw
  states: {}

connections:
- [blocks_wavfile_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
