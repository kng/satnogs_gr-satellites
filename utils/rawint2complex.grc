options:
  parameters:
    author: sa2kng
    generate_options: no_gui
    id: rawint2complex
    output_language: python
    run_options: run
    title: satnogs raw int16 to complex
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_file
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: raw_file
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/16768
    type: complex
  states: {}
- name: out_file
  id: parameter
  parameters:
    short_id: o
    type: str
    value: ''
  states: {}
- name: raw_file
  id: parameter
  parameters:
    short_id: f
    type: str
    value: ''
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
