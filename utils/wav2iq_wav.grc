options:
  parameters:
    author: Daniel Ekman <knegge@gmail.com>
    description: convert mono 48k wav/ogg to iq wav at 24k
    generate_options: no_gui
    id: wav2iq_wav
    output_language: python
    run_options: run
    title: wav to iq wav
  states: {}

blocks:
- name: filter_cutoff
  id: variable
  parameters:
    value: samp_rate // 4
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, filter_cutoff, filter_transition)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: observation.iq.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate / 2)
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: observation.ogg
    repeat: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: samp_rate // 4
    decim: '2'
    samp_rate: samp_rate
    taps: taps
    type: fcf
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_wavfile_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
