options:
  parameters:
    author: sa2kng, some parts from satnogs_bpsk
    description: 'replay iq.raw files to udp iq. Example use with: gr_satellites <sat> --samp_rate  48000 --iq --udp --udp_raw --udp_port 57356'
    generate_options: no_gui
    id: iqdump2udp
    output_language: python
    run_options: run
    title: SatNOGS IQ dump to UDP IQ
  states: {}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: raw_file
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/16768
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: int(samp_rate)
    type: complex
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: udp_dump_host
    port: udp_dump_port
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: raw_file
  id: parameter
  parameters:
    label: Input file from satnogs iq dump
    short_id: f
    type: str
    value: ''
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: s
    type: str
    value: '48000'
  states: {}
- name: udp_dump_host
  id: parameter
  parameters:
    label: host/ip to bind udp sink
    short_id: u
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: udp_dump_port
  id: parameter
  parameters:
    label: host port for udp sink
    short_id: p
    type: intx
    value: '57356'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_1, '0']
- [blocks_throttle_1, '0', blocks_udp_sink_0_0_0, '0']

metadata:
  file_format: 1
