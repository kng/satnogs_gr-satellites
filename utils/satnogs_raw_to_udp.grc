options:
  parameters:
    author: sa2kng, some parts from satnogs_bpsk
    description: replay iq.raw files to udp audio/iq
    generate_options: no_gui
    id: satnogs_raw_to_udp
    output_language: python
    run_options: run
    title: satnogs raw to udp
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: satnogs.find_decimation(baudrate, 2, audio_samp_rate,sps)
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.5e-2'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.015'
    type: complex
  states: {}
- name: analog_agc2_xx_0_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: complex
  states: {}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: '1200.0'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: raw_file
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16383.0'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/16768
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '16383'
    type: complex
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: Add a frequency offset
    phase_inc: 2.0 * math.pi * (if_freq / audio_samp_rate)
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: baudrate*decimation
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      Same output as GQRX UDP Audio
      gr-satellites --udp
      Select if_freq to suit you needs, 12000 or 1500
    eof: 'True'
    ipaddr: udp_dest_audio
    port: udp_port_audio
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    comment: 'made for: gr-satellites --iq --udp'
    eof: 'True'
    ipaddr: udp_dest_iq
    port: udp_port_iq
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import satnogs
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.42*audio_samp_rate/2.0
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: 0.05 * audio_samp_rate
    win: firdes.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '80'
    nfilts: '32'
    rrate: audio_samp_rate/(baudrate*decimation)
    type: ccf
  states: {}
- name: raw_file
  id: parameter
  parameters:
    short_id: f
    type: str
    value: ''
  states: {}
- name: udp_dest_audio
  id: parameter
  parameters:
    comment: |-
      set to 127.0.0.1 to activate
      empty to deactivate
    short_id: a
    type: str
    value: 127.0.0.1
  states: {}
- name: udp_dest_iq
  id: parameter
  parameters:
    comment: |-
      set to 127.0.0.1 to activate
      empty to deactivate
    short_id: q
    type: str
    value: 127.0.0.1
  states: {}
- name: udp_port_audio
  id: parameter
  parameters:
    type: intx
    value: '7355'
  states: {}
- name: udp_port_iq
  id: parameter
  parameters:
    type: intx
    value: '7356'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_agc2_xx_0_0, '0', low_pass_filter_0_0, '0']
- [analog_agc2_xx_0_1, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_float_to_short_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_1, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', blocks_rotator_cc_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_agc2_xx_0_0, '0']
- [virtual_source_0, '0', analog_agc2_xx_0, '0']
- [virtual_source_0_0, '0', analog_agc2_xx_0_1, '0']

metadata:
  file_format: 1
